# Keil uVision project final.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: final33 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: DIO.c DIO.h std_macros.h C8051F020.h test1.c
